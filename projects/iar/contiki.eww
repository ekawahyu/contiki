<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\conectric-rime-gw.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\conectric-rime-oc.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\conectric-rime-pls.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\conectric-rime-rht.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\conectric-rime-router.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\conectric-rime-rs485.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\conectric-rime-sub.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\conectric-rime-sw.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\conectric-rime-timer-test.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\conectric-rime-usb.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\conectric-rime-wi.ewp</path>
  </project>
  <batchBuild/>
</workspace>


