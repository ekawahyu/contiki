# IAR project contiki.ewp, settings and files
configuration cc2530-cc2530dk-udp-ipv6-server (8051, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl8051Normal.h
  General.OGChipSelectMenu: CC2530F256 CC2530F256
  ICC8051.CCDefines: chip=cc2530; AUTOSTART_ENABLE=1; PROJECT_CONF_H="project-conf.h"; CONTIKI_WITH_RIME=1; NETSTACK_CONF_WITH_RIME=1; CONTIKI_WITH_IPV6=1; NETSTACK_CONF_WITH_IPV6=1
  ICC8051.CCDiagSuppress: Pa050, Pa082
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\..\; ..\..\examples\u-mote\udp-ipv6; ..\..\platform\; ..\..\platform\u-mote\; ..\..\platform\u-mote\dev\; ..\..\cpu\; ..\..\cpu\cc253x\; ..\..\cpu\cc253x\dev\; ..\..\cpu\cc253x\usb\common; ..\..\dev\lsm330dlc\; ..\..\dev\ad7689\; ..\..\core\; ..\..\core\dev\; ..\..\core\lib\; ..\..\core\net\; ..\..\core\net\ip\; ..\..\core\net\ipv6\; ..\..\core\net\rpl\; ..\..\core\net\mac\; ..\..\core\net\rime\; ..\..\core\sys\
  ICC8051.CCOptLevel: 0
  ICC8051.CCOptStrategy: 2
  ICC8051.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_CC2530F256_banked.xcl
configuration cc2530-cc2530dk-udp-ipv6-client (8051, debug)
  as the first configuration, except:
  group core/dev
    ../../core/dev/: leds.c nullradio.c serial-line.c slip.c
  group core/lib
    ../../core/lib/: aes-128.c assert.c ccm-star.c crc16.c gcr.c ifft.c list.c me.c me_tabs.c memb.c mmem.c petsciiconv.c print-stats.c ringbuf.c ringbufindex.c sensors.c settings.c trickle-timer.c
  group core/net
    ../../core/net/: link-stats.c linkaddr.c nbr-table.c net-debug.c netstack.c packetbuf.c queuebuf.c
  group core/net/ip
    ../../core/net/ip/: dhcpc.c ip64-addr.c psock.c resolv.c simple-udp.c slipdev.c tcp-socket.c tcpip.c udp-socket.c uip-nameserver.c uip-packetqueue.c uip-split.c uip-udp-packet.c uiplib.c
  group core/net/ipv6
    ../../core/net/ipv6/: sicslowpan.c uip-ds6-nbr.c uip-ds6-route.c uip-ds6.c uip-icmp6.c uip-nd6.c uip6.c
  group core/net/ipv6/multicast
    ../../core/net/ipv6/multicast/: roll-tm.c smrf.c uip-mcast6-route.c uip-mcast6-stats.c
  group core/net/llsec
    ../../core/net/llsec/: anti-replay.c ccm-star-packetbuf.c nullsec.c
  group core/net/llsec/noncoresec
    ../../core/net/llsec/NONCORESEC/: noncoresec.c
  group core/net/mac
    ../../core/net/mac/: csma.c frame802154.c frame802154e-ie.c framer-802154.c framer-nullmac.c mac-sequence.c mac.c nordc.c nullmac.c nullrdc-noframer.c nullrdc.c phase.c
  group core/net/mac/contikimac
    ../../core/net/mac/CONTIKIMAC/: contikimac.c
  group core/net/mac/cxmac
    ../../core/net/mac/cxmac/: cxmac.c
  group core/net/mac/sicslowmac
    ../../core/net/mac/sicslowmac/: sicslowmac.c
  group core/net/rime
    ../../core/net/rime/: abc.c announcement.c broadcast-announcement.c broadcast.c chameleon-bitopt.c chameleon-raw.c chameleon.c channel.c collect-link-estimate.c collect-neighbor.c collect.c ipolite.c mesh.c multihop.c neighbor-discovery.c netflood.c packetqueue.c polite-announcement.c polite.c rime.c rimestats.c rmh.c route-discovery.c route.c rucb.c rudolph1.c rudolph2.c runicast.c stbroadcast.c stunicast.c timesynch.c trickle.c unicast.c
  group core/net/rpl
    ../../core/net/rpl/: rpl-dag-root.c rpl-dag.c rpl-ext-header.c rpl-icmp6.c rpl-mrhof.c rpl-nbr-policy.c rpl-ns.c rpl-of0.c rpl-timers.c rpl.c
  group core/sys
    ../../core/sys/: arg.c autostart.c compower.c ctimer.c energest.c etimer.c mt.c process.c procinit.c rtimer.c stimer.c timer.c
  group cpu/cc253x
    ../../cpu/cc253x/: 8051def.h cc253x-SDCC.h cc253x.h rtimer-arch.c soc.c stack.c
  group cpu/cc253x/dev
    ../../cpu/cc253x/dev/: cc2530-rf.c clock.c dma.c dma_intr.c port2-intr.c port2.c random.c uart-intr.c uart0.c uart1.c watchdog.c
  group dev/ad7689
    ../../dev/ad7689/: ad7689-sensor.c
  group dev/lsm330dlc
    ../../dev/lsm330dlc/: lsm330dlc-sensor.c
  group examples/cc2530dk
    ../../examples/cc2530dk/: blink-hello.c hello-world.c sensors-demo.c timer-test.c
  group examples/cc2530dk/border-router
    ../../examples/cc2530dk/BORDER-ROUTER/: border-router.c
    ../../examples/cc2530dk/border-router/: slip-bridge.c
  group examples/cc2530dk/udp-ipv6
    ../../examples/cc2530dk/udp-ipv6/: client.c ping6.c server.c
  group examples/efgrid-mote
    ../../examples/efgrid-mote/: timer-test.c
  group examples/efgrid-mote/border-router
    ../../examples/EFGRID-MOTE/BORDER-ROUTER/: border-router.c
    ../../examples/efgrid-mote/border-router/: slip-bridge.c
  group examples/efgrid-mote/rime
    ../../examples/efgrid-mote/rime/: example-dongle.c example-mote.c
  group examples/efgrid-mote/udp-ipv6
    ../../examples/EFGRID-MOTE/udp-ipv6/: client.c server.c
    ../../examples/efgrid-mote/udp-ipv6/: ping6.c project-conf.h
  group examples/smac-2530/rime
    ../../examples/smac-2530/rime/: example-abc.c example-broadcast.c example-dongle.c example-mote.c example-unicast.c
  group examples/u-mote
    ../../examples/u-mote/: blink-hello.c hello-world.c project-conf.h sensors-demo.c timer-test.c
  group examples/u-mote/rime
    ../../examples/u-mote/rime/: example-broadcast.c example-unicast.c
  group examples/u-mote/rime/abc
    ../../examples/u-mote/rime/abc/: example-abc.c example-dongle.c example-mote.c project-conf.h
  group examples/u-mote/rime/mesh
    ../../examples/u-mote/rime/mesh/: example-mesh.c project-conf.h
  group examples/u-mote/udp-ipv6
    ../../examples/u-mote/udp-ipv6/: client.c ping6.c project-conf.h server.c
  group platform/cc2530dk
    ../../platform/cc2530dk/: contiki-main.c debug.c putchar.c uip-debug.c viztool.c
  group platform/cc2530dk/dev
    ../../platform/cc2530dk/dev/: adc-sensor.c button-sensor.c leds-arch.c slip-arch.c smartrf-sensors.c usb-serial.c
  group platform/efgrid-mote
    ../../platform/efgrid-mote/: contiki-conf.h uip-debug.c
    ../../platform/EFGRID-MOTE/: contiki-main.c debug.c putchar.c viztool.c
  group platform/efgrid-mote/dev
    ../../platform/EFGRID-MOTE/dev/: adc-sensor.c button-sensor.c modbus-line.c
    ../../platform/efgrid-mote/dev/: efgrid-sensors.c gpio-arch.c leds-arch.c rs485-arch.c slip-arch.c spi-arch.c
  group platform/smac-2530
    ../../platform/SMAC-2530/: contiki-main.c debug.c putchar.c
    ../../platform/smac-2530/: uip-debug.c viztool.c
  group platform/smac-2530/dev
    ../../platform/smac-2530/dev/: adc-sensor.c gpio-arch.c leds-arch.c slip-arch.c smac-2530-sensors.c spi-arch.c
    ../../platform/SMAC-2530/dev/: button-sensor.c usb-serial.c
  group platform/u-mote
    ../../platform/u-mote/: contiki-conf.h contiki-main.c debug.c putchar.c uip-debug.c viztool.c
  group platform/u-mote/dev
    ../../platform/u-mote/dev/: adc-sensor.c button-sensor.c gpio-arch.c leds-arch.c slip-arch.c spi-arch.c u-mote-sensors.c usb-serial.c
