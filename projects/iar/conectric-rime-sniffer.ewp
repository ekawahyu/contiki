# IAR project conectric-rime-sniffer.ewp, settings and files
configuration Release (8051)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl8051Normal.h
  General.OGChipSelectMenu: CC2530F256 CC2530F256
  ICC8051.CCDefines: chip=cc2530; WATCHDOG=1; AUTOSTART_ENABLE=1; PROJECT_CONF_H="project-conf.h"; CONTIKI_WITH_RIME=1; NETSTACK_CONF_WITH_RIME=1; CONTIKI_WITH_IPV6=0; NETSTACK_CONF_WITH_IPV6=0; CONTIKI_WITH_RPL=0; RPL_CONF_WITH_NON_STORING=1
  ICC8051.CCDiagSuppress: Pa050, Pa082
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\..\; ..\..\examples\conectric\rime-sniffer\; ..\..\platform\; ..\..\platform\conectric\; ..\..\platform\conectric\dev\; ..\..\cpu\; ..\..\cpu\cc253x\; ..\..\cpu\cc253x\dev\; ..\..\cpu\cc253x\usb\common\; ..\..\dev\sht21\; ..\..\core\; ..\..\core\dev\; ..\..\core\lib\; ..\..\core\net\; ..\..\core\net\ip\; ..\..\core\net\ipv6\; ..\..\core\net\rpl\; ..\..\core\net\mac\; ..\..\core\net\rime\; ..\..\core\sys\
  ICC8051.CCOptLevel: 2
  ICC8051.CCOptStrategy: 2
  ICC8051.IccLang: 0
  prebuild: CMD.EXE /C "C:\Program Files\Git\git-bash.exe" ../../platform/conectric/tools/version.sh
  XLINK.XclFile: ..\..\platform\conectric\CC2530F256_banked.xcl
  group core/dev
    ../../core/dev/: leds.c nullradio.c serial-line.c slip.c
  group core/lib
    ../../core/lib/: aes-128.c assert.c ccm-star.c crc16.c gcr.c ifft.c list.c me.c me_tabs.c memb.c mmem.c petsciiconv.c print-stats.c ringbuf.c ringbufindex.c sensors.c settings.c trickle-timer.c
  group core/net
    ../../core/net/: link-stats.c linkaddr.c nbr-table.c net-debug.c netstack.c packetbuf.c queuebuf.c
  group core/net/ip
    ../../core/net/ip/: dhcpc.c ip64-addr.c psock.c resolv.c simple-udp.c slipdev.c tcp-socket.c tcpip.c udp-socket.c uip-nameserver.c uip-packetqueue.c uip-split.c uip-udp-packet.c uiplib.c
  group core/net/ipv6
    ../../core/net/ipv6/: sicslowpan.c uip-ds6-nbr.c uip-ds6-route.c uip-ds6.c uip-icmp6.c uip-nd6.c uip6.c
  group core/net/ipv6/multicast
    ../../core/net/ipv6/multicast/: roll-tm.c smrf.c uip-mcast6-route.c uip-mcast6-stats.c
  group core/net/llsec
    ../../core/net/llsec/: anti-replay.c ccm-star-packetbuf.c nullsec.c
  group core/net/llsec/noncoresec
    ../../core/net/llsec/noncoresec/: noncoresec.c
  group core/net/mac
    ../../core/net/mac/: csma.c frame802154.c frame802154e-ie.c framer-802154.c framer-nullmac.c mac-sequence.c mac.c nordc.c nullmac.c nullrdc-noframer.c nullrdc.c phase.c
  group core/net/mac/contikimac
    ../../core/net/mac/contikimac/: contikimac.c
  group core/net/mac/cxmac
    ../../core/net/mac/cxmac/: cxmac.c
  group core/net/mac/sicslowmac
    ../../core/net/mac/sicslowmac/: sicslowmac.c
  group core/net/rime
    ../../core/net/rime/: abc.c announcement.c broadcast-announcement.c broadcast.c burst.c chameleon-bitopt.c chameleon-raw.c chameleon.c channel.c collect-link-estimate.c collect-neighbor.c collect.c conectric.c iburst.c ipolite.c mesh.c multicast-linkaddr.c multicast.c multihop.c neighbor-discovery.c netflood.c packetqueue.c polite-announcement.c polite.c rime.c rimestats.c rmh.c route-discovery.c route.c rucb.c rudolph1.c rudolph2.c runicast.c stbroadcast.c stunicast.c timesynch.c trickle.c unicast.c
  group core/net/rpl
    ../../core/net/rpl/: rpl-dag-root.c rpl-dag.c rpl-ext-header.c rpl-icmp6.c rpl-mrhof.c rpl-nbr-policy.c rpl-ns.c rpl-of0.c rpl-timers.c rpl.c
  group core/sys
    ../../core/sys/: arg.c autostart.c compower.c ctimer.c energest.c etimer.c mt.c process.c procinit.c rtimer.c stimer.c timer.c
  group cpu/cc253x
    ../../cpu/cc253x/: 8051def.h cc253x-SDCC.h cc253x.h flash-logging.c rtimer-arch.c soc.c stack.c
  group cpu/cc253x/dev
    ../../cpu/cc253x/dev/: cc2530-rf.c clock.c dma.c dma_intr.c flash.c gpio.c port2-intr.c port2.c random.c spi.c spi1.c uart-intr.c uart0.c uart1.c watchdog.c
  group cpu/cc253x/usb
    ../../cpu/cc253x/usb/: cdc-acm-descriptors.c usb-arch.c
  group cpu/cc253x/usb/common
    ../../cpu/cc253x/usb/common/: usb-core.c
  group cpu/cc253x/usb/common/cdc-acm
    ../../cpu/cc253x/usb/common/cdc-acm/: cdc-acm.c
  group dev
    ../../dev/sht21/: sht21-sensor.c sht21.c
  group examples/conectric
    ../../examples/conectric/: blink-hello.c hello-world.c sensors-demo.c
    ../../examples/CONECTRIC/: command.c command.h timer-test.c
  group examples/conectric/rime-sniffer
    ../../examples/CONECTRIC/RIME-SNIFFER/: netstack.c
    ../../examples/conectric/rime-sniffer/: project-conf.h sniffer.c stub-rdc.c
  group platform/conectric
    ../../platform/CONECTRIC/: config.c contiki-main.c
    ../../platform/conectric/: debug.c putchar.c
  group platform/conectric/dev
    ../../platform/conectric/dev/: adc-sensor.c button-sensor.c conectric-sensors.c gpio-arch.c leds-arch.c modbus-crc16.c rs485-arch.c slip-arch.c spi-arch.c
    ../../platform/CONECTRIC/dev/: modbus-line.c
